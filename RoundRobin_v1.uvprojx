# Keil uVision project RoundRobin_v1.uvprojx, settings and files
target TM4C123 (5060750::V5.06 update 6 (build 750)::.\ARMCC)
  device: TM4C1230H6PM Texas Instruments
  pack: Keil.TM4C_DFP.1.1.0
  cpu: IROM(0x00000000,0x040000) IRAM(0x20000000,0x008000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: RoundRobin_v1
  c flags: Optim=1 OneElfS=1 v6Lang=1 v6LangP=1 wLevel=2
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x8000
  group osKernel
    ./: AntonOS_Kernel.c AntonOS_Kernel.h AntonOS_Kernel.s AntonOS_KernelConfig.h semaphore.c semaphore.h queue.c queue.h
  group New Group
    ./: main.c
software components: CMSIS:CORE 5.0.2, Device:Startup 1.0.1
